options:
  parameters:
    generate_options: qt_gui
    id: untitled2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: capture
  id: variable
  parameters:
    value: 1 if toggle == 0 else 0
  states: {}
- name: file_select
  id: variable_qtgui_chooser
  parameters:
    comment: |-
      File sink overwrites the selected file, 
      keep standby file selected until ready to use
    label: File Selector RX
    label0: Capture 1
    label1: Capture 2
    label2: Capture 3
    label3: Standby
    num_opts: '4'
    option0: C:\Users\Alex Watkins\Desktop\gnu projects\Garage door opener - Copy\Garage door opener - Copy\Capture_1.grc
    option1: C:\Users\Alex Watkins\Desktop\gnu projects\Garage door opener - Copy\Garage door opener - Copy\Capture_2.grc
    option2: C:\Users\Alex Watkins\Desktop\gnu projects\Garage door opener - Copy\Garage door opener - Copy\Capture_3.grc
    option3: C:\Users\Alex Watkins\Desktop\gnu projects\Garage door opener - Copy\Garage door opener - Copy\Standby.grc
    type: string
    value: C:\Users\Alex Watkins\Desktop\gnu projects\Garage door opener - Copy\Garage door opener - Copy\Standby.grc
    widget: radio_buttons
  states: {}
- name: freq
  id: variable
  parameters:
    value: '315005000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: toggle
  id: variable_qtgui_toggle_switch
  parameters:
    initPressed: 'False'
    label: RED=TRANSMIT
    pressed: '1'
    released: '0'
    switchOffBackground: green
    switchOnBackground: red
    type: int
    value: '0'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-60'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: file_select
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file_select
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: toggle
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: capture
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '50000'
    win: window.WIN_BLACKMAN
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: bw
    fc: '0'
    fftsize: '1024'
    name: Post Squelch
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bw
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: RECEIVING
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_1
  id: qtgui_freq_sink_x
  parameters:
    bw: bw
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: TRASMITTING
    tr_level: '-80'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: bw
    center_freq0: freq
    dev_addr: '"serial=31703B2"'
    gain0: '1'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: bw
    center_freq0: freq
    dev_addr: serial=31703B2
    gain0: '22'
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', low_pass_filter_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_file_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_1_1, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
